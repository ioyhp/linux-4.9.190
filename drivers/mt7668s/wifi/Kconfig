## drivers/mt7668s/wifi/Kconfig
```kconfig
menu "mt7668"

config MTK_WIFI_ONLY
	tristate "MTK WIFI ONLY"
	default m

endmenu
```
